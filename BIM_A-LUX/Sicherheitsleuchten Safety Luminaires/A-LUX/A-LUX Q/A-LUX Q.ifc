Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0], RevitIdentifiers [VersionGUID: e055f98e-3f0b-46b0-a588-6264acc6d9bf, NumberOfSaves: 0], CoordinateReference [CoordinateBase: Gemeinsam genutzte Koordinaten]
File name: A-LUX Q.ifc
Time: 2024-09-23T16:01:34+01:00
Written by: ODA SDAI 24.12
Made in: Autodesk Revit 25.1.0.44 (DEU) - IFC 25.1.0.44

# IfcProject, 2018_01
Phase: Projekt Status

# IfcSite, Default
RefLatitude: 48, 8, 15, 359802; RefLongitude: 11, 34, 47, 783432; RefElevation: 0 m

# IfcFlowTerminal: A-LUX Q:A-LUX Q LED 4 x 3,5 W, A-LUX Q:A-LUX Q LED 4 x 3,5 W:2518097
In: Default
Type - Material: Aluminiumguss, Kunststoff - PMMA, Kunststoff -PVC, Vorgabe(1)
Type - Pset_ElementShading - Color: white
Material: Vorgabe(1)
Pset_DistributionFlowElementCommon - Reference: A-LUX Q LED 4 x 3,5 W; sets with these values: 2
