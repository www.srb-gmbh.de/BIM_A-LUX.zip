Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0], RevitIdentifiers [VersionGUID: d1299b4b-b091-49e5-80e5-cf9dd8fbcf6a, NumberOfSaves: 0], CoordinateReference [CoordinateBase: Gemeinsam genutzte Koordinaten]
File name: A-LUX R.ifc
Time: 2024-09-23T16:05:10+01:00
Written by: ODA SDAI 24.12
Made in: Autodesk Revit 25.1.0.44 (DEU) - IFC 25.1.0.44

# IfcProject, 2018_01
Phase: Projekt Status

# IfcSite, Default
RefLatitude: 48, 8, 15, 359802; RefLongitude: 11, 34, 47, 783432; RefElevation: 0 m

# IfcFlowTerminal: A-LUX R:A-LUX R LED 4 x 3,5 W, A-LUX R:A-LUX R LED 4 x 3,5 W:2518097
In: Default
Type - Material: Vorgabe(1)
Type - Pset_ElementShading - Color: white
Pset_DistributionFlowElementCommon - Reference: A-LUX R LED 4 x 3,5 W; sets with these values: 2
